# Keil uVision project test.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L151C8 STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x2800) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L1XX_MD, USE_STDPERIPH_DRIVER
  c include: ..\LIB\inc;..\HARDWARE\led;..\CORE;..\USER;..\HARDWARE\delay;..\HARDWARE\sys;..\HARDWARE\usart;..\HARDWARE\process_task;..\HARDWARE\exti;..\HARDWARE\spi;..\HARDWARE\fm17550;..\HARDWARE\lpcd;..\HARDWARE\BC28;..\HARDWARE\LOCK
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group USER
    ./: system_stm32l1xx.c main.c stm32l1xx_it.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32l1xx_md.s
  group HARDWARE
    ../HARDWARE/sys/: sys.c
    ../HARDWARE/delay/: delay.c
    ../HARDWARE/usart/: usart.c
    ../HARDWARE/led/: led.c
    ../HARDWARE/process_task/: process_task.c
    ../HARDWARE/exti/: exti.c
    ../HARDWARE/spi/: spi.c
    ../HARDWARE/fm17550/: fm17550.c
    ../HARDWARE/lpcd/: lpcd.c
    ../HARDWARE/BC28/: BC28.c
    ../HARDWARE/LOCK/: lock.c
  group LIB
    ../LIB/src/: misc.c stm32l1xx_aes_util.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dbgmcu.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_gpio.c stm32l1xx_opamp.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_syscfg.c stm32l1xx_usart.c stm32l1xx_aes.c stm32l1xx_exti.c stm32l1xx_spi.c
  group README
    ../README/: README.txt
